# Keil uVision project c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: c51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c delay.c delay.h lcd1602.h lcd1602.c keys.c keys.h timer.c timer.h at24c02.c at24c02.h ds18b20.c ds18b20.h onewire.c onewire.h
